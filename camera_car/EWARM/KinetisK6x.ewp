# IAR project KinetisK6x.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 NXP MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ARM_MATH_CM4; MK60D10
  ICCARM.CCIncludePath2: ..\cpu\inc; ..\Lib\inc; ..\cpu\CMSIS\Inc; ..\User\inc; ..\Hardware\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: KinetisK6x.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: Config\Kinetis_K60DN512K.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Hardware
    ../Hardware/src/: BMX055.c FXAS2100.c FXOS8700.c ImageSensorDriver.c LSM9DS0.c MMA8451.c MPU3050.c
  group Lib
    ../Lib/src/: MK60_ADC.c MK60_DMA.c MK60_flash.c MK60_FTM.c MK60_GPIO.c MK60_PIT.c MK60_Systick.c MK60_uart.c ProjectMath.c SCCB.c SoftIIC.c
  group Start
    ../cpu/src/: StartupC_K6X.c StartupS_K6X.s
  group User
    ../User/src/: Attitude_Calculation.c Camera.c DataStore.c direction.c DisPlayDeviceDriver.c isr.c KeyBoardDriver.c main.c Motor.c Steer.c UI.c
    ../User/inc/: Attitude_Calculation.h Camera.h DataStore.h isr.h KeyBoardDriver.h Motor.h Steer.h UI.h
